# Repository plenprojectcompany/ESPRacer-webapp

File README.md:

ESPRacer for WebApp | PLEN Project Company Inc.
===============================================================================

## ESPRacer for WebApp

[ESPRacer for WebApp](https://plenprojectcompany.github.io/ESPRacer-webapp/)

## Copyright (c) 2021,
- [Isaki](https://github.com/IsakiMatsubara)
- [PLEN Project Company Inc.](https://plen.jp)

## License
This software is released under [the MIT License](http://opensource.org/licenses/mit-license.php).

## KiCad design circuit/ESP_Racer_2025/ESP_Racer_2025.kicad_pcb

Parts:
C1, C3, C4: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C5: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: Status; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
IC1: XCL102D333CR-G; XCL103D503CRG; Manufacturer_Part_Number XCL102D333CR-G
J1: Conn_LED_1; Molex_PicoBlade_53047-0210_1x02_P1.25mm_Vertical
J2: Conn_LED_2; Molex_PicoBlade_53047-0210_1x02_P1.25mm_Vertical
J3: Conn_Servo; Molex_PicoBlade_53047-0310_1x03_P1.25mm_Vertical
J4: Conn_USB; Serial
Q3: DMG3415U; SOT23
R1, R4, R7: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3: 300; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: DRV8835DSST; SON50P300X200X80-13N; PARTREV H
U2: SFV12R-2STE1LF; FCI_SFV12R-2STE1LF; MPN SFV12R-2STE1LF
U3: ESP32-C3-WROOM-02

Connections:
+3.3V: C2.1, C4.1, IC1.6 (VOUT), R7.2, U1.12 (VCC), U3.1 (3V3)
+BATT: C1.1, C3.1, IC1.1 (VBAT), IC1.7 (L1), J3.2, Q3.2, R1.1, R6.2, U1.1 (VM)
AIN 1: U1.8 (BIN1/BPHASE), U1.10 (AIN1/APHASE), U3.17 (GPIO1/ADC1_CH1/XTAL_N)
AIN 2: U1.7 (BIN2/BENBL), U1.9 (AIN2/AENBL), U3.15 (GPIO3/ADC1_CH3)
BATT_VCC: C5.1, R4.2, R6.1, U3.18 (GPIO0/ADC1_CH0/XTAL_P)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D1.1 (K), IC1.2 (GND_1), IC1.4 (GND_2), J1.2, J2.2, J3.3, J4.3, Q3.1, R4.1, U1.6 (GND), U1.11 (MODE), U1.13 (GND), U2.10, U2.11, U2.12, U2.13 (Shield), U2.14 (Shield), U3.9 (GND), U3.19 (GND)
LED_1: R3.1, U3.3 (GPIO4/ADC1_CH4/FSPIHD/MTMS)
LED_2: R2.1, U3.4 (GPIO5/ADC2_CH0/FSPIWP/MTDI)
Motor_A: U1.2 (AOUT1), U1.4 (BOUT1), U2.4, U2.5, U2.6
Motor_B: U1.3 (AOUT2), U1.5 (BOUT2), U2.7, U2.8, U2.9
unnamed: D1.2 (A), R5.1
unnamed: IC1.3 (CE), R1.2
unnamed: IC1.5 (LX), IC1.8 (L2)
unnamed: J1.1, R3.2
unnamed: J2.1, R2.2
unnamed: Q3.3, U2.1, U2.2, U2.3
unnamed: R7.1, U3.2 (EN)
PowerLED: R5.2, U3.10 (GPIO10/FSPICS0)
Servo_PWM: J3.1, U3.5 (GPIO6/FSPICLK/MTCK)
USB_D+: J4.2, U3.14 (GPIO19/USB_D+)
USB_D-: J4.1, U3.13 (GPIO18/USB_D)

Notes on the sheet:
MODE 0: IN/INモード（慣性で停止） 1: PHASE/ENABLEモード（ブレーキで停止）
電圧監視
逆接防止

Board: 2 copper layers, 20.0 x 35.0 mm, 22 parts (1 on the bottom side), 21 nets.

File circuit/ESP_Racer_2025/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C3, C4",0603,3,10u,
"C2, C5",0603,2,0.1u,
D1,0603,1,Status,
IC1,XCL103D503CRG,1,XCL102D333CR-G,
J1,Molex_PicoBlade_53047-0210_1x02_P1.25mm_Vertical,1,Conn_LED_1,
J2,Molex_PicoBlade_53047-0210_1x02_P1.25mm_Vertical,1,Conn_LED_2,
J3,Molex_PicoBlade_53047-0310_1x03_P1.25mm_Vertical,1,Conn_Servo,
J4,Serial,1,Conn_USB,
Q3,SOT23,1,IRLML6402,
"R1, R4, R7",0603,3,10k,
"R2, R3",0603,2,300,
R5,0603,1,1k,
R6,0603,1,20k,
U1,SON50P300X200X80-13N,1,DRV8835DSST,
U2,FCI_SFV12R-2STE1LF,1,SFV12R-2STE1LF,SFV12R-2STE1LF
U3,ESP32-C3-WROOM-02,1,ESP32-C3-WROOM-02,

## Commit log

2021-05-26 プロジェクトの移動
2021-05-26 タイトルロゴ
2021-05-26 ロゴサイズの修正
2021-05-26 背景色の変更
2021-05-26 デザインの修正
2021-05-26 画像の修正
2021-05-26 色の修正
2021-05-27 スタートボタンの修正
2021-06-02 アイコンの修正
2021-06-02 名称の修正
2021-06-02 表示の修正
2021-06-02 ボタンの修正
2021-06-02 説明書の更新
2021-06-02 説明書の修正
2021-06-02 Update README.md
    renaming ESPRacer
2021-06-03 ローディング画面の修正
2021-06-09 設定の修正
2021-06-18 誤字修正
2021-09-04 fix servise worker
2022-07-22 bug fixes
2022-09-09 v1.1.3
    add display rotation notice
2022-09-10 big fixes
2025-06-25 Add files via upload
    2025年度版ESP Racer（ESP32S3対応）ソースコード
2025-07-01 add pcb design
2025-07-01 update pcb
2025-07-02 pcb fix
2025-07-02 fix pcb
2025-07-17 add PIO
2025-07-28 update firmware
2025-07-30 change LED blink
2025-07-30 fix hardware errors
2025-07-30 FIRMWARE_VER "F1.01"
2025-08-13 Restore LED pin
2025-08-14 pcb update
